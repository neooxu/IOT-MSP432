# IAR project adc14_single_conversion_repeat_timera_source.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432P401R TexasInstruments MSP432P401R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; TARGET_IS_MSP432P4XX; __MSP432P401R__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ; ..\..\..\..\driverlib\MSP432P4xx\; $TOOLKIT_DIR$\inc\TexasInstruments; $TOOLKIT_DIR$\inc\TexasInstruments\CMSIS; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ; ..\..\..\..\driverlib\MSP432P4xx\
  OBJCOPY.OOCOutputFile: adc14_single_conversion_repeat_timera_source.bin
  ILINK.IlinkOutputFile: adc14_single_conversion_repeat_timera_source.out
  ILINK.IlinkIcfFile: adc14_single_conversion_repeat_timera_source_ewarm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Libraries
    ../../../../driverlib/MSP432P4xx/ewarm/: msp432p4xx_driverlib.a
  group Source
    ./: adc14_single_conversion_repeat_timera_source.c startup_msp432p401r_ewarm.c system_msp432p401r.c
